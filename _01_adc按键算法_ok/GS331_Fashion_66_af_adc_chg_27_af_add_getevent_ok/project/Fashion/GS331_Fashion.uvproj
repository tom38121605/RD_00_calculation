# Keil uVision project GS331_Fashion.uvproj, settings and files
target GS331 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GS331 +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source Group 1
    ./Code/: PUTCHAR.C main.c i2c_VCNL3020.c i2c_VCNL3020.h
  group Common
    ../../Common/: Delay.c Common.c
  group Startup
    ../../Startup/: STARTUP.A51
