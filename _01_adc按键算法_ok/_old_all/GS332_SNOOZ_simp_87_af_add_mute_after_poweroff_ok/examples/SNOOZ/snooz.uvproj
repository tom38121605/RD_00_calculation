# Keil uVision project snooz.uvproj, settings and files
target SNOOZ (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: snooz +hex
  c flags: Optimize=3 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./: SNOOZ.c
  group Common
    ../../Common/: Common.c Delay.c
    ../../Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
  group Startup
    ../../Startup/: STARTUP.A51
